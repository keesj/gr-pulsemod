<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>base_freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>433e6</value></param>
<param><key>label</key><value>Sample frequency</value></param>
<param><key>max</key><value>500e6</value></param>
<param><key>min</key><value>400e6</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filter_decimation</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>4e6</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>selected_freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>base_freq + 919e3</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>selected_freq</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>selected_sink</value></param>
<param><key>choices</key><value>[0, 1,2]</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value></value></param>
<param><key>labels</key><value>['pulsedemod','null',"file"]</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>drop_down</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>variable_slider_0</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>50</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>100</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>analog_am_demod_cf</key>
<param><key>id</key><value>analog_am_demod_cf_0</value></param>
<param><key>audio_decim</key><value>1</value></param>
<param><key>audio_pass</key><value>5000</value></param>
<param><key>audio_stop</key><value>5500</value></param>
<param><key>chan_rate</key><value>samp_rate / filter_decimation</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0</value></param>
<param><key>input_index</key><value>0</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>num_outputs</key><value>3</value></param>
<param><key>output_index</key><value>selected_sink</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>sample</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0</value></param>
<param><key>high</key><value>0.1</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>0</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>selected_freq - base_freq </value></param>
<param><key>decim</key><value>filter_decimation</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>[0.0003989969554822892, 0.00037187765701673925, 0.00034395683906041086, 0.0003146022208966315, 0.0002830885350704193, 0.0002486104494892061, 0.00021029746858403087, 0.00016723101725801826, 0.00011846270353998989, 6.30345384706743e-05, -2.0939704975504247e-19, -7.155362254707143e-05, -0.00015248238923959434, -0.00024356230278499424, -0.00034546584356576204, -0.0004587389121297747, -0.0005837779026478529, -0.0007208077586255968, -0.0008698618039488792, -0.001030761981382966, -0.0012031011283397675, -0.00138622906524688, -0.0015792378690093756, -0.0017809522105380893, -0.0019899222534149885, -0.002204418182373047, -0.0024224300868809223, -0.0026416678447276354, -0.0028595691546797752, -0.003073306754231453, -0.003279801458120346, -0.0034757377579808235, -0.0036575838457792997, -0.0038216139655560255, -0.003963935188949108, -0.004080514889210463, -0.004167215898633003, -0.004219825379550457, -0.004234098829329014, -0.0042057940736413, -0.004130712244659662, -0.004004741553217173, -0.00382389803417027, -0.0035843702498823404, -0.0032825605012476444, -0.0029151306953281164, -0.0024790402967482805, -0.0019715905655175447, -0.0013904613442718983, -0.0007337491842918098, 1.2047427570570647e-18, 0.0008117579855024815, 0.0017019876977428794, 0.0026706180069595575, 0.0037170248106122017, 0.004840013571083546, 0.006037810817360878, 0.007308053784072399, 0.008647791109979153, 0.010053490288555622, 0.011521036736667156, 0.01304575800895691, 0.014622434042394161, 0.01624532788991928, 0.017908213660120964, 0.019604401662945747, 0.02132679708302021, 0.023067913949489594, 0.02481994405388832, 0.02657479979097843, 0.02832416631281376, 0.030059559270739555, 0.03177237883210182, 0.03345397859811783, 0.035095714032649994, 0.036689016968011856, 0.0382254533469677, 0.03969678282737732, 0.04109501838684082, 0.04241250082850456, 0.04364192858338356, 0.04477643966674805, 0.045809660106897354, 0.0467357337474823, 0.04754938930273056, 0.04824597388505936, 0.048821475356817245, 0.049272581934928894, 0.04959668591618538, 0.04979189857840538, 0.04985709860920906, 0.04979189857840538, 0.04959668591618538, 0.049272581934928894, 0.048821475356817245, 0.04824597388505936, 0.04754938930273056, 0.0467357337474823, 0.045809660106897354, 0.04477643966674805, 0.04364192858338356, 0.04241250082850456, 0.04109501838684082, 0.03969678282737732, 0.0382254533469677, 0.036689016968011856, 0.035095714032649994, 0.03345397859811783, 0.03177237883210182, 0.030059559270739555, 0.02832416631281376, 0.02657479979097843, 0.02481994405388832, 0.023067913949489594, 0.02132679708302021, 0.019604401662945747, 0.017908213660120964, 0.01624532788991928, 0.014622434042394161, 0.01304575800895691, 0.011521036736667156, 0.010053490288555622, 0.008647791109979153, 0.007308053784072399, 0.006037810817360878, 0.004840013571083546, 0.0037170248106122017, 0.0026706180069595575, 0.0017019876977428794, 0.0008117579855024815, 1.2047427570570647e-18, -0.0007337491842918098, -0.0013904613442718983, -0.0019715905655175447, -0.0024790402967482805, -0.0029151306953281164, -0.0032825605012476444, -0.0035843702498823404, -0.00382389803417027, -0.004004741553217173, -0.004130712244659662, -0.0042057940736413, -0.004234098829329014, -0.004219825379550457, -0.004167215898633003, -0.004080514889210463, -0.003963935188949108, -0.0038216139655560255, -0.0036575838457792997, -0.0034757377579808235, -0.003279801458120346, -0.003073306754231453, -0.0028595691546797752, -0.0026416678447276354, -0.0024224300868809223, -0.002204418182373047, -0.0019899222534149885, -0.0017809522105380893, -0.0015792378690093756, -0.00138622906524688, -0.0012031011283397675, -0.001030761981382966, -0.0008698618039488792, -0.0007208077586255968, -0.0005837779026478529, -0.0004587389121297747, -0.00034546584356576204, -0.00024356230278499424, -0.00015248238923959434, -7.155362254707143e-05, -2.0939704975504247e-19, 6.30345384706743e-05, 0.00011846270353998989, 0.00016723101725801826, 0.00021029746858403087, 0.0002486104494892061, 0.0002830885350704193, 0.0003146022208966315, 0.00034395683906041086, 0.00037187765701673925, 0.0003989969554822892]</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>base_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>pulsemod_pulsedemod</key>
<param><key>id</key><value>pulsemod_pulsedemod_0</value></param>
<param><key>sample_rate</key><value>samp_rate / filter_decimation</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>samp_rate / filter_decimation</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>float</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_1_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>base_freq</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>selected_freq</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>samp_rate </value></param>
<param><key>title</key><value>Input Signal</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>window.hanning</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>dynamic_range</key><value>100</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate / filter_decimation</value></param>
<param><key>title</key><value>Waterfall Plot</value></param>
<param><key>type</key><value>float</value></param>
<param><key>win</key><value>None</value></param>
</block>
<connection><source_block_id>analog_am_demod_cf_0</source_block_id><sink_block_id>blocks_threshold_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_am_demod_cf_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_am_demod_cf_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>pulsemod_pulsedemod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>analog_am_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>wxgui_fftsink2_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
